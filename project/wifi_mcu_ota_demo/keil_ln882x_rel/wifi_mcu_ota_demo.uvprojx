# Keil uVision project wifi_mcu_ota_demo.uvprojx, settings and files
target wifi_mcu_ota_demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: wifi_mcu_ota_demo
  BeforeMake: python ..\..\..\tools\user_cmd\before_build.py ..\cfg\flash_partition_cfg.json ..\cfg\flash_partition_table.h
  AfterMake: python ..\..\..\tools\user_cmd\after_build_soc.py @L
  AfterMake: ..\..\..\tools\bin\mkimage.exe cmd_app ..\..\..\lib\boot_ln882x.bin @L.bin @L.asm flashimage.bin ..\cfg\flash_partition_cfg.json ver=1.1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LN882x, ARM_MATH_CM4, MBEDTLS_CONFIG_FILE=<mbedtls_config.h>
  c include: ..\..\..\components\wifi\wifi_mac\include;..\..\..\components\wifi\wifi_mac\Common;..\..\..\components\wifi\wifi_mac\Controller\AP;..\..\..\components\wifi\wifi_mac\Controller\AP-STA;..\..\..\components\wifi\wifi_mac\Controller\ModeIF;..\..\..\components\wifi\wifi_mac\Controller\STA;..\..\..\components\wifi\wifi_mac\Controller\STA\ProtIF;..\..\..\components\wifi\wifi_mac\Core\AP-STA;..\..\..\components\wifi\wifi_mac\Core\AP-STA\M802_11e;..\..\..\components\wifi\wifi_mac\Core\AP-STA\M802_11h;..\..\..\components\wifi\wifi_mac\Core\AP-STA\M802_11i;..\..\..\components\wifi\wifi_mac\Core\AP-STA\M802_11n;..\..\..\components\wifi\wifi_mac\Core\AP-STA\ProtIF;..\..\..\components\wifi\wifi_mac\Core\STA;..\..\..\components\wifi\wifi_mac\Core\STA\M802_11e;..\..\..\components\wifi\wifi_mac\Core\STA\M802_11h;..\..\..\components\wifi\wifi_mac\Core\STA\M802_11i;..\..\..\components\wifi\wifi_mac\Core\STA\M802_11n;..\..\..\components\wifi\wifi_mac\Core\STA\M802_1x;..\..\..\components\wifi\wifi_mac\Core\STA\ProtIF;..\..\..\components\wifi\wifi_mac\Core\AP;..\..\..\components\wifi\wifi_mac\Core\AP\M802_11e;..\..\..\components\wifi\wifi_mac\Core\AP\M802_11h;..\..\..\components\wifi\wifi_mac\Core\AP\M802_11i;..\..\..\components\wifi\wifi_mac\Core\AP\M802_11n;..\..\..\components\wifi\wifi_mac\Core\AP\M802_1x;..\..\..\components\wifi\wifi_mac\Core\AP\ProtIF;..\..\..\components\wifi\wifi_mac\Core\ModeIF;..\..\..\components\wifi\wifi_mac\Edge\Host;..\..\..\components\wifi\wifi_mac\Edge\IF;..\..\..\components\wifi\wifi_mac\Edge\MACHW;..\..\..\components\wifi\wifi_mac\Edge\RF\LN;..\..\..\components\wifi\wifi_mac\Edge\RF\GENERIC_RF;..\..\..\components\wifi\wifi_mac\Edge\PHY\PHYHW\LN;..\..\..\components\wifi\wifi_mac\Edge\PHY\PHYProt\P802_11n;..\..\..\components\wifi\wifi_mac\Utils\MM;..\..\..\components\wifi\wifi_mac\Utils\QM;..\..\..\components\wifi\wifi_mac\CSL;..\..\..\components\wifi\wifi_mac\Test\MacSwTest;..\..\..\components\wifi\wifi_mac\Edge\TEMP_CAL;..\..\..\components\wifi\wifi_mac\Edge\RF_HW;..\..\..\components\wifi\wifi_mac\Edge\RF_IMG_CAL\hw_img_cal;..\..\..\components\wifi\wifi_mac\Edge\RF_IMG_CAL\image_cal;..\..\..\components\net\lwip-2.0.3\src\include;..\..\..\components\net\lwip-2.0.3\src\port;..\..\..\components\net\lwip-2.0.3\src\port\arch;..\..\..\components\wifi\wifi_if;..\..\..\components\wifi\wifi_cfg\include;..\cfg;..\bsp;..\app;..\examples;..\..\..\components\fs\nvds;..\..\..\components\fs\partition_mgr;..\..\..\components\fs\kv\kv_port;..\..\..\components\fs\kv\kv;..\..\..\components\wifi\wifi_port;..\..\..\components\atcmd;..\..\..\components\serial;..\..\..\components\wifi\wifi_manager;..\..\..\components\net\dhcpd;..\..\..\components\net\iperf;..\..\..\components\net\ping;..\..\..\components\kernel;..\..\..\components\kernel\FreeRTOS\Source\include;..\..\..\components\kernel\FreeRTOS_Adapter;..\..\..\components\kernel\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\components\utils\debug\runtime;..\..\..\components\utils\debug\reboot_trace;..\..\..\components;..\..\..\mcu\driver_ln882x\inc;..\..\..\mcu\driver_ln882x\inc\reg;..\..\..\mcu\CMSIS_5.3.0;..\..\..\mcu\ln88xx;..\..\..\components\net\mbedtls\port_ln\include;..\..\..\components\net\mbedtls\include;..\..\..\components\net\httpsclient\inc;..\..\..\components\fota\ota_agent;..\..\..\components\systemview\Config;..\..\..\components\systemview\Sample\FreeRTOSV9;..\..\..\components\systemview\SEGGER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\ln882x.sct
  link misc: --keep=main.o(no_init_data)
  group cpu
    ../../../mcu/ln88xx/: system_ln88xx.c
    ../startup/: startup_ln882x.S
  group hal_ln882x
    ../../../mcu/driver_ln882x/src/hal/: hal_syscon.c hal_uart.c hal_common.c cache.c flash.c hal_dma.c qspi.c hal_spim.c hal_gpio.c hal_interrupt.c hal_sleep.c hal_rtc.c hal_efuse.c hal_trng.c hal_adc.c hal_timer.c hal_wdt.c
  group ll_ln882x
    ../../../mcu/driver_ln882x/src/ll/: ll_gpio.c
  group bsp
    ../bsp/: serial_hw.c drv_adc_measure.c
  group util
    ../../../components/utils/debug/: art_assert.c log.c
    ../../../components/utils/fifo/: fifobuf.c
    ../../../components/utils/: crc32.c art_string.c wrap_stdio.c system_parameter.c
    ../../../components/utils/debug/CmBacktrace/: cm_backtrace.c
    ../../../components/utils/unicode_convert/: unicode_convert.c
    ../../../components/utils/reboot_trace/: reboot_trace.c
    ../../../components/utils/runtime/: runtime.c
  group app
    ../app/: main.c usr_app.c
  group FreeRTOS
    ../../../components/kernel/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../components/kernel/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../components/kernel/FreeRTOS/: hooks.c
    ../../../components/kernel/FreeRTOS/Source/portable/MemMang/: heap_5.c
  group FreeRTOS_Adapter
    ../../../components/kernel/FreeRTOS_Adapter/: freertos_debug.c freertos_mutex.c freertos_queue.c freertos_semaphore.c freertos_thread.c freertos_timer.c freertos_common.c freertos_cpuusage.c
  group serial
    ../../../components/serial/: serial.c
  group console
    ../../../components/atcmd/: console.c
  group atcmd
    ../../../components/atcmd/: at_cmd_basic.c at_cmd_wifi.c at_list.c at_parser.c at_string.c at_task.c
  group lwip_core
    ../../../components/net/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../components/net/lwip-2.0.3/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../../components/net/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip_api
    ../../../components/net/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip_netif
    ../../../components/net/lwip-2.0.3/src/netif/: ethernet.c ethernetif.c
  group lwip_port
    ../../../components/net/lwip-2.0.3/src/port/arch/: lwip_hooks.c sys_arch.c
    ../../../components/net/lwip-2.0.3/src/port/: lwipopts.h
  group lib
    ../../../lib/: arm_cortexM4lf_math.lib drv_ll_ln882x.lib wifi_ln882x.lib
  group wifi_manager
    ../../../components/wifi/wifi_manager/: wifi_manager.c
    ../../../components/wifi/wifi_port/: wifi_port.c
  group net
    ../../../components/net/ping/: ping.c
    ../../../components/net/dhcpd/: dhcp_packet.c dhcpd.c ip_allocator.c
    ../../../components/net/iperf/: iperf.c
  group examples
    ../examples/: ota_demo.c
  group fs
    ../../../components/fs/partition_mgr/: flash_partition_mgr.c
    ../../../components/fs/nvds/: ln_nvds.c
    ../../../components/fs/kv/kv/: ln_kv.c
    ../../../components/fs/kv/kv_port/: ln_kv_port.c
  group fota
    ../../../components/fota/ota_agent/: ota_image.c ota_port.c
  group mbedtls
    ../../../components/net/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls_wrapper
    ../../../components/net/mbedtls/port_ln/library/: net_sockets.c platform.c threading_alt.c timing.c
  group httpclient
    ../../../components/net/httpsclient/src/: ca_cert_def.c httpsclient.c
